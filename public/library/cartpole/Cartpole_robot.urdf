Commit message: cartpole sample arranged

File: public/library/cartpole/Cartpole_robot.urdf (robot description, URDF)
Before this commit: robot Cartpole_robot, 3 links, 2 joints
Joints:
- joint slider_to_cart: origin xyz=0.000035 0 -0.000008 rpy=0 0 0 -> xyz=0.000035 0 -0.000008 rpy=0 0 -1.570796
